options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: duration
  id: variable
  parameters:
    value: '5e-2'
  states: {}
- name: rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: rate*duration
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/scope.bin
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: oscilloscope_oscilloscope_0
  id: oscilloscope_oscilloscope
  parameters:
    channels: '2'
    comment: |-
      169.254.78.105
      169.254.91.148 R&S RTO2034
      192.168.1.43     R&S RTE1054
    ip: 192.168.1.43
    myduration: '1e-3'
    myrate: 4e5
    range: '.00004'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: '"blue"'
    color2: '"red"'
    label1: ''
    label2: ''
    nconnections: '2'
    size: int(rate*duration)
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0_0, '0']
- [oscilloscope_oscilloscope_0, '0', blocks_float_to_complex_0, '0']
- [oscilloscope_oscilloscope_0, '0', blocks_throttle_0, '0']
- [oscilloscope_oscilloscope_0, '1', blocks_float_to_complex_0, '1']
- [oscilloscope_oscilloscope_0, '1', qtgui_time_sink_x_0_0, '1']

metadata:
  file_format: 1
