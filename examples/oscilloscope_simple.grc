options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: top_block
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: oscilloscope_oscilloscope_0
  id: oscilloscope_oscilloscope
  parameters:
    channels: '4'
    ip: 127.0.0.1
    myduration: '.0001'
    myrange: '2'
    myrate: 5e5
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color2: green
    color3: black
    color4: cyan
    marker1: '1'
    marker2: '1'
    marker3: '1'
    marker4: '1'
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [oscilloscope_oscilloscope_0, '0', blocks_throttle_0, '0']
- [oscilloscope_oscilloscope_0, '1', qtgui_time_sink_x_0, '1']
- [oscilloscope_oscilloscope_0, '2', qtgui_time_sink_x_0, '2']
- [oscilloscope_oscilloscope_0, '3', qtgui_time_sink_x_0, '3']

metadata:
  file_format: 1
