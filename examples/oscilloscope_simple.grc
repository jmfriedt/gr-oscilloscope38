options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: top_block
  states: {}

blocks:
- name: myrange
  id: variable_qtgui_chooser
  parameters:
    label0: 2mV
    label1: 1V
    label2: 5V
    num_opts: '3'
    option1: '1.0'
    option2: '5.0'
    type: real
    value: '2E-3'
  states: {}
- name: myrate
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 500e3
    step: 1e5
    stop: 5e9
    value: 500e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32000/4
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: oscilloscope_oscilloscope_0
  id: oscilloscope_oscilloscope
  parameters:
    channels: '4'
    ip: 127.0.0.1
    myduration: '.0002'
    myrange: myrange
    myrate: myrate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color2: green
    color3: black
    color4: cyan
    marker1: '1'
    marker2: '1'
    marker3: '1'
    marker4: '1'
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [oscilloscope_oscilloscope_0, '0', blocks_throttle_0, '0']
- [oscilloscope_oscilloscope_0, '1', qtgui_time_sink_x_0, '1']
- [oscilloscope_oscilloscope_0, '2', qtgui_time_sink_x_0, '2']
- [oscilloscope_oscilloscope_0, '3', qtgui_time_sink_x_0, '3']

metadata:
  file_format: 1
